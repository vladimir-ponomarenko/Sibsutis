options:
  parameters:
    generate_options: qt_gui
    id: Lab4
    output_language: python
    title: Vladimir Ponomarenko
  states: {}

blocks:
- name: path_loss_db
  id: variable_qtgui_range
  parameters:
    label: UE1 Pathloss [dB]
    start: '0'
    step: '1'
    stop: '300'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 23.04e6
  states: {}
- name: zmq_hwm
  id: variable
  parameters:
    value: '-1'
  states: {}
- name: zmq_timeout
  id: variable
  parameters:
    value: '100'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2003
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_rep_sink_0_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2101
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2000
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_1
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2002
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', zeromq_rep_sink_0_1, '0']
- [blocks_multiply_const_vxx_0_1, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', zeromq_rep_sink_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_throttle2_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [zeromq_req_source_0, '0', blocks_throttle2_0, '0']
- [zeromq_req_source_1, '0', blocks_throttle2_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
